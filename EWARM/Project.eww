<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\new_boardA.ewp</path>
  </project>
  <batchBuild />
</workspace>
